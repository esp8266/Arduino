# IAR project libvariant_sam3s_ek.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM3S4 Atmel SAM3S4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __SAM3S4C__
  ICCARM.CCIncludePath2: ..\..\..\cores\sam; ..\..\..\system; ..\..
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 1
  ILINK.IlinkOutputFile: libsam3s_ek.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.IccLang: 0
  group (top)
    ../: pins_arduino.h variant.cpp variant.h
  group common
    ../../common/: cortex_handlers.cpp UART.cpp UART.h USART.cpp USART.h
