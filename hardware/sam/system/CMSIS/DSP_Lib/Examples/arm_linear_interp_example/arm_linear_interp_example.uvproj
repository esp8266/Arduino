# Keil uVision project arm_linear_interp_example.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: Cortex-M4 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE FPU2
  output: arm_linear_interp_example
  c flags: Optim=1 wLevel=2
  c define: ARM_MATH_CM4
  c include: ..\..\Include;..\..\..\CM4\CoreSupport;..\..\..\CM4\DeviceSupport\ARM\ARMCM4;..\..\Source\Common\Include
  group Source Group 1
    ./src/: arm_linear_interp_example_f32.c arm_linear_interp_data.c
    ../../Source/Common/Source/: math_helper.c
  group CMSIS DeviceSupport
    ../../../CM4/DeviceSupport/ARM/ARMCM4/: system_ARMCM4.c
    ../../../CM4/DeviceSupport/ARM/ARMCM4/startup/arm/: startup_ARMCM4.s
  group CMSIS SW_DSP_Library
    ../../Lib/intermediateFiles/: arm_cortexM4_math.lib
