# IAR project test.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM3S4 Atmel SAM3S4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __SAM3S4C__
  ICCARM.CCIncludePath2: ..\..; ..\..\..\..\variants\sam3s-ek; ..\..\..\..\system
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 1
  OBJCOPY.OOCOutputFile: test.bin
  ILINK.IlinkOutputFile: test.out
  ILINK.IlinkIcfFile: ..\..\..\..\variants\sam3s-ek\linker_scripts\iar\sam3s_ek_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.IccLang: 0
  group (top)
    ../../build_iar/Debug/Exe/: libarduino_sam3s_ek_ewarm_dbg.a
    ../../../../system/libsam/build_iar/Debug/Exe/: libsam_sam3s4c_ewarm_dbg.a
    ../: test.cpp
  group resources/sam3s_ek
    ../../../../variants/sam3s-ek/linker_scripts/iar/: sam3s_ek_flash.icf sam3s_ek_sram.icf
    ../../../../variants/sam3s-ek/debug_scripts/iar/: sam3s_ek_flash.mac sam3s_ek_sram.mac
  group variants/sam3s-ek
    ../../../../variants/sam3s-ek/: pins_arduino.h variant.cpp variant.h
