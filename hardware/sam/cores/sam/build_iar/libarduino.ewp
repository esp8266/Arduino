# IAR project libarduino.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM3S4 Atmel SAM3S4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __SAM3S4C__
  ICCARM.CCIncludePath2: ../../../variants/sam3s_ek; ../../../system
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  ILINK.IlinkOutputFile: libarduino.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.IccLang: 0
configuration Debug_sam3s-ek (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: sam3s4
  ICCARM.CCIncludePath2: ../../../variants/sam3s-ek; ../../../system
  ICCARM.IccLang: 1
  group (top)
    ../: Arduino.h binary.h HardwareSerial.cpp HardwareSerial.h itoa.c itoa.h main.cpp Print.cpp Print.h Stream.h syscalls.h syscalls_sam3.c Tone.cpp UART.cpp UART.h USART.cpp USART.h WCharacter.h WInterrupts.c wiring.c wiring.h wiring_analog.c wiring_analog.h wiring_digital.c wiring_digital.h wiring_private.h wiring_pulse.c wiring_pulse.h wiring_shift.c wiring_shift.h WMath.cpp WMath.h WString.cpp WString.h
