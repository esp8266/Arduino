# Keil uVision project arm_cortexM0l_graphic_equalizer_example.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: arm_cortexM0l_graphic_equalizer_example
  c flags: Optim=3 oTime=1
  c define: ARM_MATH_CM0
  c include: ..\..\..\..\Include;..\..\Common\Include;..\..\..\..\..\Device\ARM\ARMCM0\Include
  group Source Group 1
    ../: arm_graphic_equalizer_example_q31.c arm_graphic_equalizer_data.c
    ../../Common/Source/: math_helper.c
  group CMSIS Device
    ../: system_ARMCM0.c
    ./: startup_ARMCM0.s
  group CMSIS DSP_Library
    ../../../../Lib/ARM/: arm_cortexM0l_math.lib
